File: hardware/v1.0/sdram.kicad_sch (KiCad schematic)
At the start: 7 parts, among them U10 W9825G6KH

Commit message: Finish lpf
Other:
- moved on the sheet: C39, C40, C41, C42, C43, C44
